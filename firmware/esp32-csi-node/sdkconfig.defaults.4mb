## firmware/esp32-csi-node/sdkconfig.defaults.4mb
```kconfig
CONFIG_PARTITION_TABLE_CUSTOM_FILENAME="partitions_4mb.csv"
# CONFIG_DISPLAY_ENABLE is not set
```
